## boards/shields/mpad/Kconfig.defconfig
```kconfig
if SHIELD_MPAD

config ZMK_KEYBOARD_NAME
    default "mpad"

endif # SHIELD_MPAD
```
